# Keil uVision project chip_driver_ma104.uvprojx, settings and files
target m0plus (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: tool_timer_scheduler_m0plus (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\import;..\source;..\include;..\reference\mcu_framework;..\reference\tool_ring_buffer
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group import
    ../include/: chip_driver_ma104.h
  group source
    ../source/: chip_driver_ma104.c
  group include
    ../include/: chip_driver_ma104.h
  group reference_mcu_framework
    ../reference/mcu_framework/: fw_adc.h fw_adc_channel.h fw_base.h fw_i2cm.h fw_io.h fw_io_pin.h fw_ioint.h fw_spim.h fw_timer.h fw_usart.h
  group reference_ring_buffer
    ../reference/tool_ring_buffer/source/: tool_ring_buffer.c
    ../reference/tool_ring_buffer/: tool_ring_buffer.h
